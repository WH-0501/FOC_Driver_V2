# Keil uVision project AT32M416K8U7-4_WorkBench.uvprojx, settings and files
target AT32M416K8U7-4_WorkBench (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: AT32M416K8U7-4 ArteryTek
  pack: ArteryTek.AT32M412_416_DFP.2.0.5
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: AT32M416K8U7-4_WorkBench +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32M416K8U7_4, USE_STDPERIPH_DRIVER, PLATFORM_AT32
  c include: ..\..\libraries\drivers\inc;..\..\libraries\cmsis\cm4\core_support;..\..\libraries\cmsis\cm4\device_support;..\inc;..\Board;..\APP;..\APP\FOC
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group user
    ../src/: at32m412_416_int.c at32m412_416_wk_config.c main.c wk_system.c wk_adc.c wk_can.c wk_crc.c wk_spi.c wk_tmr.c wk_usart.c wk_dma.c wk_gpio.c
    ../Board/: board.c board_at32.c
    ../APP/FOC/: foc.c motor_fault.c
  group firmware
    ../../libraries/drivers/src/: at32m412_416_crm.c at32m412_416_tmr.c at32m412_416_gpio.c at32m412_416_usart.c at32m412_416_pwc.c at32m412_416_adc.c at32m412_416_spi.c at32m412_416_dma.c at32m412_416_debug.c at32m412_416_flash.c at32m412_416_crc.c at32m412_416_misc.c at32m412_416_scfg.c at32m412_416_can.c
  group cmsis
    ./: startup_at32m412_416.s
    ../../libraries/cmsis/cm4/device_support/: system_at32m412_416.c
