# Keil uVision project AT32M416_Bldr.uvprojx, settings and files
target AT32M416_Bldr (5060960::V5.06 update 7 (build 960)::.\ARMCOMPLIER506)
  device: AT32M416CBT7 ArteryTek
  pack: ArteryTek.AT32M412_416_DFP.2.0.5
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: AT32M416_Bldr
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: AT32M416CBT7,USE_STDPERIPH_DRIVER
  c include: ..\..\libraries\cmsis\cm4\core_support;..\..\libraries\drivers\inc;..\inc;..\..\app
  memory RVCT4: ROM 0x8000000 size 0x1000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group user
    ../src/: main.c at32m412_416_int.c at32m412_416_clock.c
  group firmware
    ../../libraries/drivers/src/: at32m412_416_crm.c at32m412_416_flash.c
  group cmsis
    ../../libraries/cmsis/cm4/device_support/: system_at32m412_416.c
    ../../libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32m412_416.s
  group app
    ../../app/flash/: flash.c
