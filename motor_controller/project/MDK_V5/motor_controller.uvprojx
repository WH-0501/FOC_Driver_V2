# Keil uVision project motor_controller.uvprojx, settings and files
target motor_controller (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: AT32M416KBU7-4 ArteryTek
  pack: ArteryTek.AT32M412_416_DFP.2.0.5
  cpu: IRAM(0x20000000,0x4000) IROM(0x08001000,0x1F000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: motor_controller +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  AfterMake: fileInfoadder .\objects\motor_controller.bin .\FoE\AX58400_AT32M416_APP.efw -ft 3
  c flags: Optim=3 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32M416KBU7_4, USE_STDPERIPH_DRIVER, PLATFORM_AT32
  c include: ..\..\libraries\drivers\inc;..\..\libraries\cmsis\cm4\core_support;..\..\libraries\cmsis\cm4\device_support;..\inc;..\APP;..\APP\config;..\APP\Driver;..\APP\FOC;..\APP\logger;..\APP\comm;..\APP\comm\transport;..\APP\comm\protocol\custom;..\APP\comm\protocol\canopen;..\Board
  memory RVCT4: ROM 0x8001000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\cst-profile.sct
  group user
    ../src/: at32m412_416_int.c at32m412_416_wk_config.c main.c wk_system.c wk_adc.c wk_can.c wk_spi.c wk_tmr.c wk_usart.c wk_dma.c wk_gpio.c
  group firmware
    ../../libraries/drivers/src/: at32m412_416_crm.c at32m412_416_tmr.c at32m412_416_gpio.c at32m412_416_usart.c at32m412_416_pwc.c at32m412_416_adc.c at32m412_416_spi.c at32m412_416_dma.c at32m412_416_debug.c at32m412_416_flash.c at32m412_416_misc.c at32m412_416_scfg.c at32m412_416_can.c
  group cmsis
    ./: startup_at32m412_416.s
    ../../libraries/cmsis/cm4/device_support/: system_at32m412_416.c
  group Board
    ../Board/: board.c board_at32.c dwt_profile_delay.c
  group FOC
    ../APP/FOC/: current_sense.c encoder.c foc.c foc_calibration.c foc_fault.c foc_fsm.c foc_filter.c foc_math.c foc_sense.c foc_pid.c
    ../APP/: motor.c mc_interface.c
    ../APP/FOC/sweep/: sweep_chirp.c sweep_engine.c sweep_prepare.c foc_sweep.c sweep_record.c sweep_protocol.c
  group Driver
    ../APP/Driver/gate/: gate_driver.c mp6540.c
    ../APP/Driver/: motor_driver.c
    ../APP/Driver/encoder/: kth71xx.c
    ../APP/Driver/storage/: eeprom.c flash.c
  group Config
    ../APP/config/: motor_config.c motor_config_storage_ops.c
  group Logger
    ../APP/logger/: logger.c Debug.c
  group Comm
    ../APP/comm/: comm.c
    ../APP/comm/transport/: can_port_at32.c
    ../APP/comm/protocol/custom/: can_fd_custom.c can_fd_custom_codec.c can_fd_custom_iap.c iap_upgrade.c
    ../APP/comm/protocol/canopen/: canopen.c
